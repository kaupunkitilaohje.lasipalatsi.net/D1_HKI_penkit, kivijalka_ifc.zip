Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2]
File name: N:\2000\316762_HKI_DIMA_koordinointi_6_2022_5_2023\4_Tuote\Kaupunkikalusteiden 3D mallit\IFC\IFC\D2_HKI_penkit, kivijalka.ifc
Time: 2022-09-05T09:57:50
Author: FITK31777
Organization: WSP
Written by: ggRhinoIFC v2.2.11.0 by Geometry Gym Pty Ltd built 2022-05-25T11:32:32
Made in: ggRhinoIFC v2.2.11.0 - Rhino7 Plug-in by Geometry Gym Pty Ltd
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorization

# IfcBuildingElementProxy (24)
In: By Parent
Name | IfcRoot_Description
2 x PUURIMA, istuinosa | tiheäsyinen mänty tai tammi / kuultokäsittely tai peittomaalaus / Värit: (Kivikaupunki Valtti color 3145, RAL 7021 tai RAL 8015) (Aluekeskus ja asuinalue RAL 7021 tai RAL 8015) | Properties - IfcEntity: IfcFurnishingElement
13 x PUURIMA, istuinosa | tiheäsyinen mänty tai tammi / kuultokäsittely tai peittomaalaus / Värit: (Kivikaupunki Valtti color 3145, RAL 7021 tai RAL 8015) (Aluekeskus ja asuinalue RAL 7021 tai RAL 8015)
2 x TERÄSLATTA | RST, 70 x 7
7 x
